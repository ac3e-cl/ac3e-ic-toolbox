v {xschem version=3.4.8 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
N 0 -60 0 -30 {lab=VIN}
N 0 30 0 60 {lab=VOUT}
C {devices/res.sym} 0 0 0 0 {name=Rsmoke value=1234 m=1}
C {devices/lab_pin.sym} 0 -60 0 0 {name=p1 lab=VIN}
C {devices/lab_pin.sym} 0 60 0 0 {name=p2 lab=VOUT}
